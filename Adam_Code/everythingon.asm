	#include <p16F690.inc>
	__config (_INTRC_OSC_NOCLKOUT&_WDT_OFF&_PWRTE_OFF&_MCLRE_OFF&_CP_OFF&_BOR_OFF&_IESO_OFF&_FCMEN_OFF)

	cblock 0x20
	DELAY
	DELAY1
	NUM
	endc
	
	org 0
START
	BANKSEL ADCON0
	BCF ADCON0,0
	BANKSEL ANSEL
	bcf ANSEL,0
	BANKSEL ANSELH
	BCF ANSELH,0
	BANKSEL TRISC
	CLRF TRISC
	BANKSEL PORTC
	CLRF PORTC
	MOVLW 5
	MOVWF NUM
	MOVF NUM,PORTC
HALT
	MOVLW 0
	GOTO HALT
	;MOVLW 7
	;MOVWF PORTC
	
LOOP
	BANKSEL NUM
	INCF NUM
	BANKSEL PORTC
	MOVF NUM,PORTC

DELAYLOOP
	DECFSZ DELAY
	GOTO DELAYLOOP
	DECFSZ DELAY1
	GOTO DELAYLOOP
	GOTO LOOP
	end